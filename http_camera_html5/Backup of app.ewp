# IAR project Backup of app.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STM32F10xxC ST STM32F10xxC
  ICCARM.CCIncludePath2: source\include; source\Libraries\CMSIS\CM3\CoreSupport; source\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; source\Libraries\STM32F10x_StdPeriph_Driver\inc
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: app.bin
  ILINK.IlinkOutputFile: app.out
  ILINK.IlinkIcfFile: app.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ./: app.icf
    source/: base64.c device.c httpd.c httputil.c iic.c main.c mcu_init.c ov2640.c sha1.c stm32f10x_it.c system_stm32f10x.c util.c webpage.c websocket.c weibo.c
  group cmsis
    source/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group ewarmv5.4
    source/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_hd.s
  group ewarmv5.4/stdPeriph_Driver
    source/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_bkp.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group w5500
    source/w5500/: md5.c socket.c SPI2.c w5500.c
